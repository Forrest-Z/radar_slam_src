Commit message: os_fcar

File: arbe_slam/config/radar_kit.urdf (robot description, URDF)
Before this commit: robot radar_robot, 5 links, 4 joints
Joints:
- joint joint_base_wheel1: origin xyz=0 1.5 0 rpy=0.1 0 0 -> xyz=0 0.5 0 rpy=0.1 0 0
